# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H750xx, USE_HAL_DRIVER, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\finsh;.;rt-thread\include;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;.\board\CubeMX_Config\Core\Inc;.\packages\freemodbus-latest\modbus\rtu;.\packages\freemodbus-latest\modbus\include;.\rt-thread\components\drivers\include\drivers;.\packages\freemodbus-latest\modbus;.\packages\freemodbus-latest\port;.\applications;.\board\CubeMX_Config\Drivers\STM32H7xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./applications/: my_dac.c filter.c crc16.c modbus.c uart.c env.c debug.c sensor_calib.c ADS8688.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c backtrace.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpuport.c cpu_cache.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c ringbuffer.c workqueue.c dataqueue.c waitqueue.c ringblk_buf.c pipe.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    ./rt-thread/components/drivers/hwtimer/: hwtimer.c
    ./rt-thread/components/drivers/misc/: adc.c
  group Drivers
    board/: board.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c drv_spi.c
    ./board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    ./libraries/HAL_Drivers/: drv_hwtimer.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: components.c mem.c device.c object.c timer.c kservice.c idle.c mempool.c ipc.c clock.c scheduler.c irq.c thread.c
  group Libraries
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ./libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c
    ./board/CubeMX_Config/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c
