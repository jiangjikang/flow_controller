# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743II ST STM32H743II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; STM32H750xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc; rt-thread\components\libc\compilers\common; rt-thread\components\libc\posix\io\poll; rt-thread\libcpu\arm\common; rt-thread\components\drivers\include; libraries\HAL_Drivers; libraries\HAL_Drivers\config; libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include; libraries\STM32H7xx_HAL\CMSIS\Include; rt-thread\components\libc\posix\io\stdio; rt-thread\components\finsh; .; rt-thread\libcpu\arm\cortex-m7; rt-thread\components\libc\compilers\common\extension; board; rt-thread\components\libc\posix\ipc; rt-thread\include; board\CubeMX_Config\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/common/: time.c stdlib.c
    rt-thread/components/libc/compilers/dlib/: syscall_mem.c environ.c syscall_write.c syscalls.c syscall_close.c syscall_lseek.c syscall_read.c syscall_remove.c syscall_open.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c div0.c backtrace.c
    rt-thread/libcpu/arm/cortex-m7/: cpuport.c cpu_cache.c context_iar.S
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: ringblk_buf.c workqueue.c ringbuffer.c completion.c waitqueue.c pipe.c dataqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h750xx.s
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_common.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group Kernel
    rt-thread/src/: mempool.c kservice.c irq.c components.c device.c timer.c mem.c thread.c ipc.c idle.c object.c clock.c scheduler.c
  group Libraries
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_uart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal.c stm32h7xx_hal_usart.c stm32h7xx_hal_cec.c stm32h7xx_hal_pwr.c stm32h7xx_hal_dma.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_comp.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_rng.c stm32h7xx_hal_mdma.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
